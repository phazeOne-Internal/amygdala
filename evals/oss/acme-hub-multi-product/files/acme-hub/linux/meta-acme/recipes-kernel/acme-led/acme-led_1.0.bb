SUMMARY = "Acme LED ring driver"
LICENSE = "CLOSED"
inherit module
SRC_URI = "file://acme_led.c file://Makefile"
